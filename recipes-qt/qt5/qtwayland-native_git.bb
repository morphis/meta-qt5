require qt5-git.inc
require ${PN}.inc

PR = "${INC_PR}.0"

SRCREV = "ede872db1cdfdc2810c2dd29edd5fb6e1cdac0f5"
